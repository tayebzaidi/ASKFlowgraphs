options:
  parameters:
    author: gpellaeon
    generate_options: qt_gui
    id: ook_receiver
    output_language: python
    title: OOK Receiver
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.00001'
    step: '0.00001'
    stop: '0.01'
    value: '0.00328'
  states: {}
- name: baseband_freq
  id: variable
  parameters:
    value: '500'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 432.867e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: int (samp_rate / baseband_freq)
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: Threshold
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.03'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /run/media/gpellaeon/ubuntu20_04/home/pellaeon/Development/SDR/GRFlowgraphs/ook/digital_output.txt
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '4'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: alpha
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.06'
    init: '0'
    low: '0.04'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 2]'
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"soapy=0,driver=lime"'
    bb_gain0: '0'
    freq0: carrier_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: carrier_freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '3'
    size: '600000'
    srate: samp_rate
    tr_level: '0.07'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '0.15'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '0'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samples_per_symbol / 4)
    interp: '1'
    taps: '1'
    type: fff
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_rms_xx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_char_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_map_bb_0, '0']
- [blocks_rms_xx_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_threshold_ff_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_threshold_ff_0_0, '0', rational_resampler_xxx_0, '0']
- [digital_map_bb_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_char_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
